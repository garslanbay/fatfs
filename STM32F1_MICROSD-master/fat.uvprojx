# Keil uVision project fat.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: fat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD
  c include: .\fatfs;.\stm_lib\inc;.\bsp;.\cmsis;.\cmsis_boot;..\STM32F1_MICROSD-master
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c stm32f10x_fatfs.c startup_stm32f10x_md.s
    ./cmsis_boot/: system_stm32f10x.c
    ./fatfs/: diskio.c ff.c SPI_MSD_Driver.c
    ./stm_lib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c
    ./bsp/: open103z_systick.c
